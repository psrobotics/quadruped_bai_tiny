# Autodesk Inventor part: SM06B
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2021-02
Part Number: SM06B
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: SM06B
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
