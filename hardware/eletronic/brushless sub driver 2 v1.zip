# Autodesk Inventor part: 0402
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2021-02
Part Number: 0402
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: 0402
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
