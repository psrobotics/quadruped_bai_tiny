# Autodesk Inventor part: C1206
Saved by Autodesk Inventor 2019.4 (Build 234336000, 336)
## iProperties
Created: 2021-02
Part Number: C1206
Material: Generic
Document SubType Name: Modeling
Designer: Administrator
Density: 1 g/cm^3
Appearance: Default
Title: C1206
Author: Administrator
## Design history (mm, degrees)
feature "Body1"
body "Solid1"
